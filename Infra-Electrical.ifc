Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [ReferenceView]
File name: Infra-Electrical.ifc
Time: 2026-06-23T11:54:08
Written by: Sketchup-IFC-manager 5.6.0 / SketchUp 2026 (26.2.242)
Made in: BIM_Tools - Sketchup_IFC_manager - 5.6.0

# IfcProject, ifc silly sample scene - project
Description: Demystifying IFC with a playful scene using diverse building elements and compositions.

# IfcSite (6)
RefElevation: 0 mm
Name | Description
environment - site | A sample scene environment, showcasing the surrounding landscape.
road parking - site | A designated parking area, providing space for vehicles.
road river bridge - site | The site of the road river bridge, connecting different areas.
rail river bridge - site | The site of the rail river bridge, facilitating train crossings.
road rail bridge - site | The site of the road rail bridge, supporting both road and rail traffic.
road - site | A designated parking area, providing space for vehicles.

# IfcBridge: arched (2)
Description: A strong rail bridge, supporting trains as they cross over.; PredefinedType: ARCHED

# IfcBridge: girder, road river bridge
Description: A sturdy bridge, spanning the river and connecting roads.; PredefinedType: GIRDER

# IfcBuildingElementProxy: geo-reference
In: environment - site
Type - Description: The reference point for transforming the local engineering coordinate system into the coordinate reference system of the underlying map.; ElementType: origin; PredefinedType: USERDEFINED
Material: virtual_black

# IfcDiscreteAccessory: charging station - gap filler grout
In: road parking - site
Type - Description: Gap filler grout, ensuring a secure fit for the charging station components.; ElementType: filler; PredefinedType: FILLER
Material: cement_grout_generic

# IfcDistributionChamberElement: sewer manhole (2)
In: road river bridge - site
Type - Description: A manhole, providing access to the sewer system.; ElementType: manhole; PredefinedType: MANHOLE
Material: Default; Group: road wastewater system

# IfcDistributionSystem, road wastewater system
Description: A comprehensive wastewater system, ensuring efficient sewage management.; PredefinedType: SEWAGE

# IfcElectricAppliance: charging station
In: road parking - site
Type - Description: An electric vehicle charging station, providing power for EVs.; ElementType: electric vehicle charging station; PredefinedType: USERDEFINED
Material: metal_sheetmetal_generic

# IfcFooting: charging station - foundation block
In: road parking - site
Type - Description: A solid foundation block, providing support for the charging station.; ElementType: pad_footing; PredefinedType: PAD_FOOTING
Material: concrete_reinforced_prefab

# IfcRoad: road (5)
Classification: E-CAE Road (CCI Construction)
Name | Description
road parking - road | A well-constructed road, connecting various parts of the infrastructure.
2 x bridge road connection | A connection point, linking the bridge road to other infrastructure.
2 x road | A well-constructed road, connecting various parts of the infrastructure.
